// SPDX-License-Identifier: (GPL-2.0-only OR BSD-2-Clause)

#include <dt-bindings/interrupt-controller/irq.h>
#include <dt-bindings/interrupt-controller/arm-gic.h>
#include <dt-bindings/clock/en7523-clk.h>
#include <dt-bindings/phy/phy.h>
#include <dt-bindings/phy/airoha,an7581-usb-phy.h>
#include <dt-bindings/soc/airoha,scu-ssr.h>
#include <dt-bindings/reset/airoha,en7581-reset.h>
#include <dt-bindings/leds/common.h>
#include <dt-bindings/thermal/thermal.h>

/ {
	interrupt-parent = <&gic>;
	#address-cells = <2>;
	#size-cells = <2>;

	reserved-memory {
		#address-cells = <2>;
		#size-cells = <2>;
		ranges;

		atf@80000000 {
			no-map;
			reg = <0x0 0x80000000 0x0 0x200000>;
		};

		npu_binary: npu-binary@84000000 {
			no-map;
			reg = <0x0 0x84000000 0x0 0xa00000>;
		};

		qdma0_buf: qdma0-buf@87000000 {
			no-map;
			reg = <0x0 0x87000000 0x0 0x2000000>;
		};

		qdma1_buf: qdma1-buf@89000000 {
			no-map;
			reg = <0x0 0x89000000 0x0 0x1000000>;
		};

		npu_pkt: npu-pkt@8a000000 {
			no-map;
			reg = <0x0 0x8a000000 0x0 0x2c00000>;
		};

		npu_txpkt: npu-txpkt@8cc00000 {
			no-map;
			reg = <0x0 0x8cc00000 0x0 0x4000000>;
		};

		npu_txbufid: npu-txbufid@90c00000 {
			no-map;
			reg = <0x0 0x90c00000 0x0 0x6800>;
		};
	};

	psci {
		compatible = "arm,psci-1.0";
		method = "smc";
	};

	cpus {
		#address-cells = <1>;
		#size-cells = <0>;

		cpu-map {
			cluster0 {
				core0 {
					cpu = <&cpu0>;
				};

				core1 {
					cpu = <&cpu1>;
				};

				core2 {
					cpu = <&cpu2>;
				};

				core3 {
					cpu = <&cpu3>;
				};
			};
		};

		cpu0: cpu@0 {
			device_type = "cpu";
			compatible = "arm,cortex-a53";
			reg = <0x0>;
			operating-points-v2 = <&cpu_opp_table>;
			enable-method = "psci";
			clocks = <&cpufreq>;
			clock-names = "cpu";
			power-domains = <&cpufreq>;
			power-domain-names = "perf";
			next-level-cache = <&l2>;
			#cooling-cells = <2>;
		};

		cpu1: cpu@1 {
			device_type = "cpu";
			compatible = "arm,cortex-a53";
			reg = <0x1>;
			operating-points-v2 = <&cpu_opp_table>;
			enable-method = "psci";
			clocks = <&cpufreq>;
			clock-names = "cpu";
			power-domains = <&cpufreq>;
			power-domain-names = "perf";
			next-level-cache = <&l2>;
			#cooling-cells = <2>;
		};

		cpu2: cpu@2 {
			device_type = "cpu";
			compatible = "arm,cortex-a53";
			reg = <0x2>;
			operating-points-v2 = <&cpu_opp_table>;
			enable-method = "psci";
			clocks = <&cpufreq>;
			clock-names = "cpu";
			power-domains = <&cpufreq>;
			power-domain-names = "perf";
			next-level-cache = <&l2>;
			#cooling-cells = <2>;
		};

		cpu3: cpu@3 {
			device_type = "cpu";
			compatible = "arm,cortex-a53";
			reg = <0x3>;
			operating-points-v2 = <&cpu_opp_table>;
			enable-method = "psci";
			clocks = <&cpufreq>;
			clock-names = "cpu";
			power-domains = <&cpufreq>;
			power-domain-names = "perf";
			next-level-cache = <&l2>;
			#cooling-cells = <2>;
		};

		l2: l2-cache {
			compatible = "cache";
			cache-size = <0x80000>;
			cache-line-size = <64>;
			cache-level = <2>;
			cache-unified;
		};
	};

	cpufreq: cpufreq {
		reg = <0x0 0x1fa20000 0x0 0x2c0>, <0x0 0x1efbe000 0x0 0x800>;
		reg-names = "chip-scu", "mcucfg";
		compatible = "airoha,en7581-cpufreq";

		operating-points-v2 = <&cpu_smcc_opp_table>;

		#power-domain-cells = <0>;
		#clock-cells = <0>;
	};

	cpu_opp_table: opp-table {
		compatible = "operating-points-v2";
		opp-shared;

		opp-500000000 {
			opp-hz = /bits/ 64 <500000000>;
			required-opps = <&smcc_opp0>;
		};

		opp-550000000 {
			opp-hz = /bits/ 64 <550000000>;
			required-opps = <&smcc_opp1>;
		};

		opp-600000000 {
			opp-hz = /bits/ 64 <600000000>;
			required-opps = <&smcc_opp2>;
		};

		opp-650000000 {
			opp-hz = /bits/ 64 <650000000>;
			required-opps = <&smcc_opp3>;
		};

		opp-7000000000 {
			opp-hz = /bits/ 64 <700000000>;
			required-opps = <&smcc_opp4>;
		};

		opp-7500000000 {
			opp-hz = /bits/ 64 <750000000>;
			required-opps = <&smcc_opp5>;
		};

		opp-8000000000 {
			opp-hz = /bits/ 64 <800000000>;
			required-opps = <&smcc_opp6>;
		};

		opp-8500000000 {
			opp-hz = /bits/ 64 <850000000>;
			required-opps = <&smcc_opp7>;
		};

		opp-9000000000 {
			opp-hz = /bits/ 64 <900000000>;
			required-opps = <&smcc_opp8>;
		};

		opp-9500000000 {
			opp-hz = /bits/ 64 <950000000>;
			required-opps = <&smcc_opp9>;
		};

		opp-10000000000 {
			opp-hz = /bits/ 64 <1000000000>;
			required-opps = <&smcc_opp10>;
		};

		opp-10500000000 {
			opp-hz = /bits/ 64 <1050000000>;
			required-opps = <&smcc_opp11>;
		};

		opp-11000000000 {
			opp-hz = /bits/ 64 <1100000000>;
			required-opps = <&smcc_opp12>;
		};

		opp-11500000000 {
			opp-hz = /bits/ 64 <1150000000>;
			required-opps = <&smcc_opp13>;
		};

		opp-12000000000 {
			opp-hz = /bits/ 64 <1200000000>;
			required-opps = <&smcc_opp14>;
		};
	};

	cpu_smcc_opp_table: opp-table-cpu-smcc {
		compatible = "operating-points-v2";

		smcc_opp0: opp0 {
			opp-level = <0>;
		};

		smcc_opp1: opp1 {
			opp-level = <1>;
		};

		smcc_opp2: opp2 {
			opp-level = <2>;
		};

		smcc_opp3: opp3 {
			opp-level = <3>;
		};

		smcc_opp4: opp4 {
			opp-level = <4>;
		};

		smcc_opp5: opp5 {
			opp-level = <5>;
		};

		smcc_opp6: opp6 {
			opp-level = <6>;
		};

		smcc_opp7: opp7 {
			opp-level = <7>;
		};

		smcc_opp8: opp8 {
			opp-level = <8>;
		};

		smcc_opp9: opp9 {
			opp-level = <9>;
		};

		smcc_opp10: opp10 {
			opp-level = <10>;
		};

		smcc_opp11: opp11 {
			opp-level = <11>;
		};

		smcc_opp12: opp12 {
			opp-level = <12>;
		};

		smcc_opp13: opp13 {
			opp-level = <13>;
		};

		smcc_opp14: opp14 {
			opp-level = <14>;
		};
	};

	timer {
		compatible = "arm,armv8-timer";
		interrupt-parent = <&gic>;
		interrupts = <GIC_PPI 13 IRQ_TYPE_LEVEL_LOW>,
			     <GIC_PPI 14 IRQ_TYPE_LEVEL_LOW>,
			     <GIC_PPI 11 IRQ_TYPE_LEVEL_LOW>,
			     <GIC_PPI 10 IRQ_TYPE_LEVEL_LOW>;
	};

	thermal-zones {
		cpu_thermal: cpu-thermal {
			polling-delay-passive = <0>;
			polling-delay = <0>;

			thermal-sensors = <&thermal 0>;

			trips {
				cpu_hot: cpu-hot {
					temperature = <95000>;
					hysteresis = <1000>;
					type = "hot";
				};

				cpu-critical {
					temperature = <110000>;
					hysteresis = <1000>;
					type = "critical";
				};
			};

			cooling-maps {
				map0 {
					trip = <&cpu_hot>;
					cooling-device = <&cpu0 THERMAL_NO_LIMIT THERMAL_NO_LIMIT>,
							 <&cpu1 THERMAL_NO_LIMIT THERMAL_NO_LIMIT>,
							 <&cpu2 THERMAL_NO_LIMIT THERMAL_NO_LIMIT>,
							 <&cpu3 THERMAL_NO_LIMIT THERMAL_NO_LIMIT>;
				};
			};
		};
	};

	clk25m: oscillator {
		compatible = "fixed-clock";
		#clock-cells = <0>;
		clock-frequency = <25000000>;
		clock-output-names = "clkxtal";
	};

	vmmc_3v3: regulator-vmmc-3v3 {
		compatible = "regulator-fixed";
		regulator-name = "vmmc";
		regulator-min-microvolt = <3300000>;
		regulator-max-microvolt = <3300000>;
		regulator-always-on;
	};

	sound: sound {
		compatible = "airoha,an7581-wm8960-sound";

		status = "disabled";

		platform {
			sound-dai = <&afe>;
		};
	};

	soc {
		compatible = "simple-bus";
		#address-cells = <2>;
		#size-cells = <2>;
		ranges;

		gic: interrupt-controller@9000000 {
			compatible = "arm,gic-v3";
			interrupt-controller;
			#interrupt-cells = <3>;
			#address-cells = <1>;
			#size-cells = <1>;
			reg = <0x0 0x09000000 0x0 0x20000>,
			      <0x0 0x09080000 0x0 0x80000>,
			      <0x0 0x09400000 0x0 0x2000>,
			      <0x0 0x09500000 0x0 0x2000>,
			      <0x0 0x09600000 0x0 0x20000>;
			interrupts = <GIC_PPI 9 IRQ_TYPE_LEVEL_LOW>;
		};

		uart1: serial@1fbf0000 {
			compatible = "ns16550";
			reg = <0x0 0x1fbf0000 0x0 0x30>;
			reg-io-width = <4>;
			reg-shift = <2>;
			interrupts = <GIC_SPI 18 IRQ_TYPE_LEVEL_HIGH>;
			clock-frequency = <1843200>;
		};

		watchdog@1fbf0100 {
			compatible = "airoha,en7581-wdt";
			reg = <0x0 0x1fbf0100 0x0 0x38>;

			clocks = <&scuclk EN7523_CLK_BUS>;
			clock-names = "bus";
		};

		uart2: serial@1fbf0300 {
			compatible = "airoha,en7523-uart";
			reg = <0x0 0x1fbf0300 0x0 0x30>;
			reg-io-width = <4>;
			reg-shift = <2>;
			interrupts = <GIC_SPI 32 IRQ_TYPE_LEVEL_HIGH>;
			clock-frequency = <7372800>;

			status = "disabled";
		};

		hsuart3: serial@1fbe1000 {
			compatible = "airoha,en7523-uart";
			reg = <0x0 0x1fbe1000 0x0 0x40>;
			reg-io-width = <4>;
			reg-shift = <2>;
			interrupts = <GIC_SPI 54 IRQ_TYPE_LEVEL_HIGH>;
			clock-frequency = <7372800>;

			status = "disabled";
		};

		afe: afe@1fbe2200 {
			compatible = "airoha,an7581-afe";
			reg = <0x0 0x1fbe2200 0x0 0x9000>;

			interrupts = <GIC_SPI 48 IRQ_TYPE_LEVEL_HIGH>;
		};

		uart4: serial@1fbf0600 {
			compatible = "airoha,en7523-uart";
			reg = <0x0 0x1fbf0600 0x0 0x30>;
			reg-io-width = <4>;
			reg-shift = <2>;
			interrupts = <GIC_SPI 61 IRQ_TYPE_LEVEL_HIGH>;
			clock-frequency = <7372800>;

			status = "disabled";
		};

		uart5: serial@1fbf0700 {
			compatible = "airoha,en7523-uart";
			reg = <0x0 0x1fbf0700 0x0 0x30>;
			reg-io-width = <4>;
			reg-shift = <2>;
			interrupts = <GIC_SPI 18 IRQ_TYPE_LEVEL_HIGH>;
			clock-frequency = <7372800>;

			status = "disabled";
		};

		pon_pcs: pcs@1fa08000 {
			compatible = "airoha,an7581-pcs-pon";
			reg = <0x0 0x1fa08000 0x0 0x1000>,
			      <0x0 0x1fa80000 0x0 0x60>,
			      <0x0 0x1fa80a00 0x0 0x164>,
			      <0x0 0x1fa84000 0x0 0x450>,
			      <0x0 0x1fa85900 0x0 0x338>,
			      <0x0 0x1fa86000 0x0 0x300>,
			      <0x0 0x1fa8a000 0x0 0x1000>,
			      <0x0 0x1fa8b000 0x0 0x1000>;
			reg-names = "xfi_mac", "hsgmii_an", "hsgmii_pcs",
				    "multi_sgmii", "usxgmii",
				    "hsgmii_rate_adp", "xfi_ana", "xfi_pma";

			resets = <&scuclk EN7581_XPON_MAC_RST>,
				 <&scuclk EN7581_XPON_PHY_RST>;
			reset-names = "mac", "phy";

			airoha,scu = <&scuclk>;
		};

		eth_pcs: pcs@1fa09000 {
			compatible = "airoha,an7581-pcs-eth";
			reg = <0x0 0x1fa09000 0x0 0x1000>,
			      <0x0 0x1fa70000 0x0 0x60>,
			      <0x0 0x1fa70a00 0x0 0x164>,
			      <0x0 0x1fa74000 0x0 0x450>,
			      <0x0 0x1fa75900 0x0 0x338>,
			      <0x0 0x1fa76000 0x0 0x300>,
			      <0x0 0x1fa7a000 0x0 0x100
